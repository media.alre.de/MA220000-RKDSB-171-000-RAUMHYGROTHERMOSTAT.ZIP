Properties of the parts of a building model (IFC2X3)

# File
Description: Raumhygrothermostat, Aufputz, 24 VAC oder 230 VAC, 10…35 °C, 30…100% r.H., 2 Wechsler, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA220000, Raumhygrothermostat, Aufputz, 24 VAC oder 230 VAC, 10…35 °C, 30…100% r.H., 2 Wechsler
In: Raum
Description: Hygro-Thermostat für die gleichzeitige Regelung oder Überwachung der Temperatur und Feuchte in Büros, Wohnräumen, Hotels aber auch Schwimmbädern, Wintergärten und Wohnungsbädern und geeignet für alle Heizungsarten. Das Gerät kann wahlweise mit 24 V~ oder 230 V~ betrieben werden. Bei elektrischen Fußbodenheizungen ist darauf zu achten, dass die Leistung der Heizung auch bei Dauerbetrieb den Estrich nicht überhitzen kann. Bei Warmwasserheizungen sind auf den Heizausgang max. 10 stromlos geschlossene, oder auf den Kühlausgang max. 5 stromlos offene Ventile anzuschließen. Im Kühlfall sind max. 5 stromlos geschlossenen Ventile auf den Kühlausgang oder max. 10 stromlos offene Ventile auf den Heizausgang anzuschließen. Gegebenenfalls benötigte Temperaturbegrenzungen müssen zusätzlich installiert werden.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA220000; ModelLabel: RKDSB-171.000; GlobalTradeItemNumber: 4050528049926; ProductURL: https://alre.de/produkt_MA220000
Pset_Specification - NominalLength: 0.1107 m; NominalWidth: 0.11 m; NominalDepth: 0.026 m; NetWeight: 0.135
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Breite: 110; Höhe: 110.7; Tiefe: 26; RAL-Nummer: 9010; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Wechsler (NO/NC); Messbereich: 10; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Bimetall; Schutzart (NEMA): sonstige; Verdeckte Bedienung: no; Max. Spannung der Kontakte: 230; Max. Kontaktbelastung: 10; Differenzwert: 1; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA220000.pdf
